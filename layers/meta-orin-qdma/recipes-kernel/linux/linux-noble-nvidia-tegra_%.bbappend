FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://qdma-host.cfg"
